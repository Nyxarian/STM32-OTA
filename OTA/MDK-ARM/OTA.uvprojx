# Keil uVision project OTA.uvprojx, settings and files
target OTA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: OTA +hex
  AfterMake: "F:\keil5\ARM\ARMCC\bin\fromelf.exe" --bin --output ".\OTA\OTA.bin" ".\OTA\OTA.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE,USER_VECT_TAB_ADDRESS,VECT_TAB_OFFSET=0x00010000U
  c include: ../Core/Inc;../BSP;../App;../lvgl;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./UI;./Apps/Tetris;./Apps/Settings;./Apps/Monitor;./Apps/Wifi;.\Apps\Weather;.\Apps\SystemUpgrade
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8010000 size 0x6ffe0
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Apps/SystemUpgrade
    ./Apps/SystemUpgrade/: system_upgrade_page.c system_upgrade_page.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/App
    ../App/: ota_ui.c ota_ui_font.c
  group Application/BSP
    ../BSP/: BSP_Key.c
  group Middlewares/LVGL/Porting
    ../lvgl/porting/: lv_port_lcd_stm32.c lv_port_indev.c
  group Middlewares/LVGL
    ../lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../lvgl/src/display/: lv_display.c
    ../lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_rgb565.c
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../lvgl/src/font/: lv_font.c
    ../lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../lvgl/src/layouts/: lv_layout.c
    ../lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../lvgl/src/: lv_init.c
    ../lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../lvgl/src/osal/: lv_os.c lv_os_none.c
    ../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../lvgl/src/stdlib/: lv_mem.c
    ../lvgl/src/themes/default/: lv_theme_default.c
    ../lvgl/src/themes/: lv_theme.c
    ../lvgl/src/tick/: lv_tick.c
    ../lvgl/src/widgets/bar/: lv_bar.c
    ../lvgl/src/widgets/button/: lv_button.c
    ../lvgl/src/widgets/label/: lv_label.c
    ../lvgl/src/widgets/image/: lv_image.c
  group UI
    ./UI/: ui_app.c ui_wallpaper.c ui_nav.c ui_pages_boot.c ui_pages_desktop.c ui_app.h ui_theme.c ui_theme.h ui_components.c ui_components.h ui_pages_placeholder.c
    ../App/: boot_flag.c
  group Apps/Tetris
    ./Apps/Tetris/: tetris_game.c tetris_game.h tetris_page.c tetris_page.h
  group Apps/Settings
    ./Apps/Settings/: settings_page.c settings_page.h
  group Apps/Monitor
    ./Apps/Monitor/: monitor_page.c monitor_page.h monitor_stats.c monitor_stats.h
  group Apps/Wifi
    ./Apps/Wifi/: wifi_uart.c wifi_uart.h wifi_at_test.c wifi_at_test.h at_test_page.c at_test_page.h wifi_manager.c wifi_manager.h wifi_config.h wifi_page.c wifi_page.h
  group Apps/weather
    ./Apps/Weather/: weather_page.c weather_page.h
software components: CMSIS:CORE 4.3.0
